# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWEARE\NB;..\HARDWEARE\USART;..\HARDWEARE\LED;..\HARDWEARE\KEY;..\HARDWEARE\SimplePrintf;..\HARDWEARE\NB_TIME;..\HARDWEARE\WDG;..\HARDWEARE\BlueTooth;..\HARDWEARE\Systerm_Init;..\WAKEUP\WakeUp;..\SLEEPMODE\SleepMode;..\RTC\rtc;..\HARDWEARE\BLUE_TIME;..\HARDWEARE\BLUE_DATA_DEAL;..\FLASH;..\HARDWEARE\COMMUNICATION_TO_APP;..\HARDWEARE\IOSTREAM;..\HARDWEARE\OLED;..\HARDWEARE\BEEP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c
    D:/百度网盘资料/STM32战舰版/战舰V3 资料盘(A盘)/4，程序源码/4，STM32启动文件/: startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWEARE
    ../HARDWEARE/Systerm_Init/: Systerm_Init.c
    ../HARDWEARE/NB/: NB.c
    ../HARDWEARE/USART/: usart.c
    ../HARDWEARE/LED/: led.c
    ../HARDWEARE/KEY/: key.c
    ../HARDWEARE/NB_TIME/: NB_time.c
    ../HARDWEARE/WDG/: wdg.c
    ../HARDWEARE/BlueTooth/: BlueTooth.c
    ../HARDWEARE/SimplePrintf/: SimplePrintf.c
    ../HARDWEARE/BLUE_TIME/: Blue_time.c
    ../HARDWEARE/BLUE_DATA_DEAL/: BlueData_Deal.c
    ../HARDWEARE/COMMUNICATION_TO_APP/: communication_to_app.c
    ../HARDWEARE/OLED/: oled.c
    ../HARDWEARE/BEEP/: beep.c
  group WAKEUP
    ../WAKEUP/WakeUp/: wakeup.c
  group SLEEPMODE
    ../SLEEPMODE/SleepMode/: SleepMode.c
  group RTC
    ../RTC/rtc/: rtc.c
  group FLASH
    ../FLASH/: flash.c
